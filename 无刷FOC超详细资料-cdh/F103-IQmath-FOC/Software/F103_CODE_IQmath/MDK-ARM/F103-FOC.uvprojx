# Keil uVision project F103-FOC.uvprojx, settings and files
target F103-FOC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: F103-FOC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,ARM_MATH_CM3
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/APP;../User/Function;../User/PeripheralsDriver;../User/MCUDriver;../User/RTT;../User/IQmath;../User/IQmath/rvmdk-cm3;../User/FocControl;../User/FocFramework
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../User/APP/: APPMain.c
  group MCUDriver
    ../User/MCUDriver/: MCUDriverMain.c Motor1ADC1.c Motor1GPIO.c Motor1SPI1.c Motor1TIM1Pwm.c Timer.c
  group PerDriver
    ../User/PeripheralsDriver/: PerDriverMain.c TouchDriver.c LedDriver.c SysManage.c SDS.c
  group Function
    ../User/Function/: AngleCalibrationFunc.c FunctionMain.c CanBus.c UartBus.c StartupMusic.c
  group FocControl
    ../User/FocControl/: FocControl.c
  group FocFramework
    ../User/FocFramework/: FocMath.c AngleEncoder.c FocSVPWM.c
  group IQmath
    ../User/IQmath/rvmdk-cm3/: IQmathLib-cm3.lib
    ../User/IQmath/: IQmathLib.h
  group RTT
    ../User/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
